## config/boards/shields/charybdis/Kconfig.defconfig
```kconfig
if SHIELD_charybdis_LEFT

config ZMK_KEYBOARD_NAME
	default "charybdis"

config ZMK_SPLIT_BLE_ROLE_CENTRAL
	default y

endif
```
